# IAR project STM32F746G_DISCO.ewp, settings and files
configuration STM32F746G_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/Components/ft5336; ../Drivers/BSP; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F746G_DISCO.hex
  ILINK.IlinkOutputFile: STM32F746G_DISCO.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: STM32F746G_DISCO.ipcf
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Drivers/BSP
    ../Drivers/BSP/: stm32746g_discovery_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/Components
    ../Drivers/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Bold_otf_12_4bpp_0.cpp Font_Asap_Bold_otf_15_4bpp_0.cpp Font_Asap_Bold_otf_18_4bpp_0.cpp Font_Asap_Bold_otf_18_4bpp_4.cpp Font_Asap_Bold_otf_46_4bpp_0.cpp Font_Asap_Regular_11_4bpp_0.cpp Font_Asap_Regular_12_4bpp_0.cpp Font_Asap_Regular_12_4bpp_4.cpp Font_Asap_Regular_15_4bpp_0.cpp Font_Asap_Regular_18_4bpp_0.cpp Font_ipaexg_12_4bpp_0.cpp Font_ipaexg_12_4bpp_10.cpp Font_ipaexg_12_4bpp_11.cpp Font_ipaexg_12_4bpp_12.cpp Font_ipaexg_12_4bpp_13.cpp Font_ipaexg_12_4bpp_14.cpp Font_ipaexg_12_4bpp_15.cpp Font_ipaexg_12_4bpp_16.cpp Font_ipaexg_12_4bpp_17.cpp Font_ipaexg_12_4bpp_18.cpp Font_ipaexg_12_4bpp_6.cpp Font_ipaexg_12_4bpp_9.cpp Font_ipaexg_18_4bpp_0.cpp Font_ipaexg_18_4bpp_17.cpp Font_ipaexg_18_4bpp_6.cpp Font_NotoSans_Regular_12_4bpp_0.cpp Font_NotoSans_Regular_18_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Bold_otf_12_4bpp.cpp Kerning_Asap_Bold_otf_15_4bpp.cpp Kerning_Asap_Bold_otf_18_4bpp.cpp Kerning_Asap_Bold_otf_46_4bpp.cpp Kerning_Asap_Regular_11_4bpp.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_ipaexg_12_4bpp.cpp Kerning_ipaexg_18_4bpp.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Kerning_NotoSans_Regular_18_4bpp.cpp Table_Asap_Bold_otf_12_4bpp.cpp Table_Asap_Bold_otf_15_4bpp.cpp Table_Asap_Bold_otf_18_4bpp.cpp Table_Asap_Bold_otf_46_4bpp.cpp Table_Asap_Regular_11_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_ipaexg_12_4bpp.cpp Table_ipaexg_18_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_18_4bpp.cpp UnmappedDataFont.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/customcontrols_screen/: CustomControlsViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/easingequation_screen/: EasingEquationViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/graph_screen/: GraphViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/mainmenu_screen/: MainMenuViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/containers/: McuLoadWidgetBase.cpp
    ../TouchGFX/generated/gui_generated/src/productpresenter_screen/: ProductPresenterViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp
    ../TouchGFX/generated/images/src/Graph/: image_blue_area_button_active.cpp image_blue_area_button_inactive.cpp image_blue_dots_button_active.cpp image_blue_dots_button_inactive.cpp image_blue_line_button_active.cpp image_blue_line_button_inactive.cpp image_graph_background_bottom.cpp image_graph_menu_button.cpp image_graph_menu_button_pressed.cpp image_graph_toggle_button_active.cpp image_graph_toggle_button_inactive.cpp image_graph_top_menu_activate_button.cpp image_graph_top_menu_line.cpp image_green_area_button_active.cpp image_green_area_button_inactive.cpp image_green_dots_button_active.cpp image_green_dots_button_inactive.cpp image_green_line_button_active.cpp image_green_line_button_inactive.cpp image_half_circle_toggle_button_active.cpp image_half_circle_toggle_button_inactive.cpp image_new_graph.cpp image_new_graph_pressed.cpp image_new_pie_chart.cpp image_new_pie_chart_pressed.cpp image_pie_chart_legend_blue.cpp image_pie_chart_legend_blue_active.cpp image_pie_chart_legend_green.cpp image_pie_chart_legend_green_active.cpp image_pie_chart_legend_orange.cpp image_pie_chart_legend_orange_active.cpp image_pie_chart_legend_purple.cpp image_pie_chart_legend_purple_active.cpp image_pie_chart_legend_red.cpp image_pie_chart_legend_red_active.cpp image_pie_chart_legend_yellow.cpp image_pie_chart_legend_yellow_active.cpp image_pie_toggle_button_active.cpp image_pie_toggle_button_inactive.cpp
    ../TouchGFX/generated/images/src/CustomControls/: image_control_center_button.cpp image_control_center_button_pressed.cpp image_control_color_wheel.cpp image_control_menu_arrow_down.cpp image_control_menu_arrow_down_inactive.cpp image_control_menu_arrow_down_pressed.cpp image_control_menu_arrow_up-inactive.cpp image_control_menu_arrow_up.cpp image_control_menu_arrow_up_pressed.cpp image_control_menu_button.cpp image_control_menu_button_pressed.cpp image_control_menu_icon_datepicker_large.cpp image_control_menu_icon_datepicker_small.cpp image_control_menu_icon_gauge_large.cpp image_control_menu_icon_gauge_small.cpp image_control_menu_icon_percentage_large.cpp image_control_menu_icon_percentage_small.cpp image_control_menu_icon_three_way_large.cpp image_control_menu_icon_three_way_small.cpp image_control_menu_shadow_bottom.cpp image_control_menu_shadow_top.cpp image_controls_background.cpp image_controls_menu_background.cpp image_controls_three_way_small_circle.cpp image_controls_wheel_background.cpp image_datepicker_bottom_shadow_overlay.cpp image_datepicker_glass_overlay.cpp image_datepicker_main_background.cpp image_datepicker_top_shadow_overlay.cpp image_gauge_background.cpp image_gauge_needle_pin.cpp image_small_circle_bin_icon_active.cpp image_small_circle_bin_icon_inactive.cpp image_small_circle_folder_icon_active.cpp image_small_circle_folder_icon_inactive.cpp image_small_circle_papers_icon_active.cpp image_small_circle_papers_icon_inactive.cpp
    ../TouchGFX/generated/images/src/MainMenu/: image_demo_button_01.cpp image_demo_button_01_pressed.cpp image_demo_button_02_03.cpp image_demo_button_02_03_pressed.cpp image_demo_button_04.cpp image_demo_button_04_pressed.cpp image_demo_button_05_06.cpp image_demo_button_05_06_pressed.cpp image_menu_demo_screen_02.cpp image_menu_demo_screen_03.cpp image_menu_demo_screen_04.cpp image_menu_demo_screen_05.cpp image_menu_stage_stretch_left_side.cpp image_menu_stage_stretch_right_side.cpp image_screen_swipe_dots_active.cpp image_screen_swipe_dots_inactive.cpp
    ../TouchGFX/generated/images/src/EasingEquation/: image_easing_background.cpp image_easing_bottom_menu.cpp image_easing_bottom_menu_active.cpp image_easing_bottom_menu_selected.cpp image_easing_dot.cpp image_easing_menu_button.cpp image_easing_menu_button_pressed.cpp image_easing_side_menu_button.cpp image_easing_side_menu_button_active.cpp image_easing_side_menu_button_selected.cpp image_graphDot.cpp
    ../TouchGFX/generated/images/src/ProductPresenter/: image_flag_dnk_active.cpp image_flag_dnk_inactive.cpp image_flag_gbr_active.cpp image_flag_gbr_inactive.cpp image_flag_jpn_active.cpp image_flag_jpn_inactive.cpp image_flag_nld_active.cpp image_flag_nld_inactive.cpp image_flag_ukr_active.cpp image_flag_ukr_inactive.cpp image_poster_image_00.cpp image_poster_image_01.cpp image_poster_image_02.cpp image_product_presenter_menu_button.cpp image_product_presenter_menu_button_pressed.cpp image_product_presenter_nav_bar.cpp image_product_presenter_next.cpp image_product_presenter_next_pressed.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp
  group TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: mcuLoadWidget.cpp
  group TouchGFX/gui/customcontrols_screen
    ../TouchGFX/gui/src/customcontrols_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
  group TouchGFX/gui/easingequation_screen
    ../TouchGFX/gui/src/easingequation_screen/: EasingEquationButton.cpp EasingEquationGraph.cpp EasingEquationInOutSelectorGroup.cpp EasingEquationPresenter.cpp EasingEquationSelector.cpp EasingEquationView.cpp
  group TouchGFX/gui/graph_screen
    ../TouchGFX/gui/src/graph_screen/graph_widget/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterVerticalAlpha.cpp
    ../TouchGFX/gui/src/graph_screen/: GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PieChart.cpp
  group TouchGFX/gui/mainmenu_screen
    ../TouchGFX/gui/src/mainmenu_screen/: MainMenuPresenter.cpp MainMenuView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/productpresenter_screen
    ../TouchGFX/gui/src/productpresenter_screen/: CollapsibleMenu.cpp ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core.a
